# Keil uVision project STM32L4xx.uvprojx, settings and files
target STM32L4xx_1024 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: STM32L4xx_1024
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM, STM32L4x_1024
  c misc: --C99
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STM32L4xx_512 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: STM32L4xx_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM, STM32L4x_512
  c misc: --C99
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32L4xx_256 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: STM32L4xx_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM, STM32L4x_256
  c misc: --C99
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
