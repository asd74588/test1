# Keil uVision project test.uvprojx, settings and files
target test (6190000::V6.19::ARMCLANG)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2000BFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: test +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32L431xx NDEBUG
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\Core\interface;..\Core\interface\FLASH;..\Core\interface\SPI;..\Core\interface\UART;..\Core\interface\Xmodem;..\Core\interface\Littlefs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Application/User/Core/Interface
    ../Core/interface/FLASH/: eeprom_emul.c eeprom_emul.h flash_bootloader.c flash_bootloader.h
    ../Core/interface/SPI/: w25qxx.c w25qxx.h
    ../Core/interface/UART/: uart_bootloader.c uart_bootloader.h
    ../Core/interface/: global.h
    ../Core/interface/Xmodem/: xmodem.c xmodem.h
    ../Core/interface/Littlefs/: lfs.c lfs.h lfs_util.c lfs_util.h lfs_port.c lfs_config.h
software components: CMSIS:CORE 5.6.0
